# Keil uVision project MOD.uvproj, settings and files
target MOD (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: MOD +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\BASE;..\HARDWARE\DELAYMS;..\HARDWARE\DS18B20;..\HARDWARE\IIC;..\HARDWARE\SMG;..\HARDWARE\TINIT;..\HARDWARE\KEYPAD
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/BASE/: Base_lib.c
    ../HARDWARE/DELAYMS/: Delayms_lib.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/SMG/: smg_lib.c
    ../HARDWARE/TINIT/: Tinit_lib.c
    ../HARDWARE/KEYPAD/: Keypad_lib.c
